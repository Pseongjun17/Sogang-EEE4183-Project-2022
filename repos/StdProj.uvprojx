# Keil uVision project StdProj.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: StdProj
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10x_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group New Group
    ./Src/: ADC.c ADC.h DOT_MATRIX.c DOT_MATRIX.h DotMatrixPattern.h GPIO.c GPIO.h KEY_MATRIX.c KEY_MATRIX.h main.c main.h TIMER.c TIMER.h USART.c USART.h GlobalParameters.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_conf.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
